# Keil uVision project robot.uvprojx, settings and files
target robot (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: robot +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../../../../../../embedi-robot/Embedi/include;../../../../../../embedi-robot/Embedi/algorithms/include;../../../../../../embedi-robot/Embedi/drivers/peripheral/include;../../../../../../embedi-robot/Embedi/drivers/platform/include;../../../../../../embedi-robot/Embedi/system/include;../../../../../../embedi-robot/Embedi/utils/include
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Embedi
    ../../../../../../embedi-robot/Embedi/algorithms/kalman/: embedi_2d_kalman.c embedi_6d_kalman.c
    ../../../../../../embedi-robot/Embedi/algorithms/math/: embedi_math.c
    ../../../../../../embedi-robot/Embedi/algorithms/pid/: embedi_pid.c
    ../../../../../../embedi-robot/Embedi/application/wheels/: embedi_wheels.c
    ../../../../../../embedi-robot/Embedi/drivers/peripheral/imu/: embedi_imu.c
    ../../../../../../embedi-robot/Embedi/drivers/peripheral/imu/mpu6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../../../../../embedi-robot/Embedi/drivers/peripheral/motor/: embedi_motor.c
    ../../../../../../embedi-robot/Embedi/drivers/platform/: embedi_delay.c embedi_flash.c embedi_i2c.c embedi_uart.c
    ../../../../../../embedi-robot/Embedi/system/: embedi_module_init.c embedi_system.c
    ../../../../../../embedi-robot/Embedi/utils/: embedi_scope.c
software components: CMSIS:CORE 4.3.0
