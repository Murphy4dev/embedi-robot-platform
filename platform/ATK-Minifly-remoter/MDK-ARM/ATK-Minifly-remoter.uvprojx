# Keil uVision project ATK-Minifly-remoter.uvprojx, settings and files
target ATK-Minifly-remoter (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: ATK-Minifly-remoter +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../../../../embedi-robot/Embedi/algorithms/include;../../../../embedi-robot/Embedi/drivers/peripheral/include;../../../../embedi-robot/Embedi/drivers/platform/include;../../../../embedi-robot/Embedi/include;../../../../embedi-robot/Embedi/system/include;../../../../embedi-robot/Embedi/utils/include;../../../../embedi-robot/Embedi/include/project/remoter;../../../../embedi-robot/Embedi/drivers/protocol/include
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Embedi
    ../../../../embedi-robot/Embedi/algorithms/kalman/: embedi_2d_kalman.c embedi_6d_kalman.c
    ../../../../embedi-robot/Embedi/algorithms/math/: embedi_math.c
    ../../../../embedi-robot/Embedi/algorithms/pid/: embedi_pid.c
    ../../../../embedi-robot/Embedi/application/quadrotor/: embedi_quadrotor.c
    ../../../../embedi-robot/Embedi/application/wheels/: embedi_wheels.c
    ../../../../embedi-robot/Embedi/drivers/platform/: embedi_delay.c embedi_flash.c embedi_i2c.c embedi_uart.c embedi_spi.c embedi_printf.c embedi_adc.c
    ../../../../embedi-robot/Embedi/drivers/peripheral/barometer/: embedi_baro.c
    ../../../../embedi-robot/Embedi/drivers/peripheral/barometer/bmp280/: embedi_bmp280.c
    ../../../../embedi-robot/Embedi/drivers/peripheral/barometer/spl06/: embedi_spl06.c
    ../../../../embedi-robot/Embedi/drivers/peripheral/imu/mpu6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../../../embedi-robot/Embedi/drivers/peripheral/imu/: embedi_imu.c
    ../../../../embedi-robot/Embedi/drivers/peripheral/motor/: embedi_motor.c
    ../../../../embedi-robot/Embedi/system/: embedi_module_init.c embedi_system.c embedi_dispatch.c
    ../../../../embedi-robot/Embedi/utils/: embedi_scope.c
    ../../../../embedi-robot/Embedi/application/remoter/: embedi_remoter.c
    ../../../../embedi-robot/Embedi/drivers/protocol/: embedi_protocol.c
    ../../../../embedi-robot/Embedi/drivers/peripheral/wireless/2_4g/: embedi_host.c
    ../../../../embedi-robot/Embedi/drivers/peripheral/wireless/2_4g/nrf24l01/: embedi_nrf24l01.c
    ../../../../embedi-robot/Embedi/drivers/peripheral/joystick/: embedi_joystick.c
    ../../../../embedi-robot/Embedi/drivers/peripheral/battery/: embedi_battery.c
    ../../../../embedi-robot/Embedi/algorithms/filter/: embedi_iir.c
software components: CMSIS:CORE 4.3.0
